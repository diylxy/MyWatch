# Keil uVision project watch.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: watch +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 flash.c main.c oled.c rtc.c internal_iic.c adc.c Terminal.c morse.c alarm.c settings.c music.c menu.c serial.c
